# Keil uVision project Prema_WyspaZaworowa1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F410RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Prema_WyspaZaworowa1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Control.c Control.h main.c MB_RTU_Slave.c MB_RTU_Slave.h NIC_Module.c NIC_Module.h Outputs.c Outputs.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
